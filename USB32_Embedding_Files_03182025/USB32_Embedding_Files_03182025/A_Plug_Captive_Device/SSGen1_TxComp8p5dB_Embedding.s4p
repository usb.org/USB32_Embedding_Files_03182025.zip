! Save cascaded4-port  S-parameter
# GHz S RI R 50
! Worked out from all points (differential pair):
!   1601 points, 300 kHz to 20 GHz, reference 50 ohm
!   strongest paths, dB at 300 kHz, 5 GHz, 10 GHz, 15 GHz, 20 GHz:
!     S31: -56.1, -16.2, -12.5, -11.4, -26.3
!     S42: -53.6, -23.5, -25.8, -26.9, -29.7
!     S43: -0.2, -24.7, -33.5, -49.0, -74.6
!     S21: -0.2, -23.1, -33.5, -54.9, -73.1
!     S41: -55.0, -18.6, -36.0, -43.2, -79.5
!     S32: -55.5, -20.5, -38.5, -48.0, -69.6
!   taken as a pair (ports 3,1 in; 4,2 out), SDD21 dB: -0.2, -15.5, -29.2, -41.9, -76.1
!   lowest |S11| = -41.3 dB at 4.538 GHz (marker M1), VSWR 1.02, Z = 50 - j0.861 ohm
!   |S11| at or under -10 dB: start of sweep to 5.234 GHz; 5.544 GHz to 6.169 GHz (625.2 MHz wide, 10.7 % of centre); 7.252 GHz to 8.073 GHz (821 MHz wide, 10.7 % of centre) (the widest 3 of 6)
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! magnitudes (dB):
! f  S11  S31  S42  S43  S21  S41  S32
! 300 kHz  -32.4  -56.1  -53.6  -0.2  -0.2  -55.0  -55.5
! 425.3 MHz  -16.8  -14.7  -16.8  -2.9  -3.0  -15.2  -14.6
! 4.538 GHz  -41.3  -21.6  -40.8  -22.8  -23.3  -17.3  -18.1
! 15.3 GHz  5.9  -6.9  -25.9  -56.0  -55.1  -45.1  -51.0
! 16.24 GHz  0.9  -39.1  -28.6  -59.9  -64.1  -58.9  -57.6
! 17.14 GHz  17.5  15.3  -25.3  -49.3  -66.4  -44.5  -42.3
! 20 GHz  4.8  -26.3  -29.7  -74.6  -73.1  -79.5  -69.6
