!Agilent Technologies,E5071C,MY46107606,A.09.30
!Date: Mon Dec 14 20:41:19 2009
!Data & Calibration Information:
!Freq	S11:SOLT4(ON)	S12:SOLT4(ON)	S13:SOLT4(ON)	S14:SOLT4(ON)
!	S21:SOLT4(ON)	S22:SOLT4(ON)	S23:SOLT4(ON)	S24:SOLT4(ON)
!	S31:SOLT4(ON)	S32:SOLT4(ON)	S33:SOLT4(ON)	S34:SOLT4(ON)
!	S41:SOLT4(ON)	S42:SOLT4(ON)	S43:SOLT4(ON)	S44:SOLT4(ON)
# Hz S dB R 50
! Worked out from all points (4-port):
!   1601 points, 300 kHz to 20 GHz, reference 50 ohm
!   strongest paths, dB at 300 kHz, 5 GHz, 10 GHz, 15 GHz, 20 GHz:
!     S21: -46.1, -18.6, -11.2, -12.9, -16.0
!     S43: -46.3, -21.7, -24.7, -26.9, -29.4
!     S41: -50.0, -30.5, -58.4, -74.8, -82.1
!     S42: -0.2, -33.1, -62.5, -86.0, -72.6
!     S31: -0.2, -36.4, -61.2, -72.2, -75.7
!     S32: -49.6, -39.5, -63.3, -83.2, -72.5
!   lowest |S11| = -41.6 dB at 2.238 GHz (marker M1), VSWR 1.02, Z = 49.6 - j0.743 ohm
!   |S11| at or under -10 dB: start of sweep to 1.271 GHz; 1.305 GHz to 2.533 GHz (1.228 GHz wide, 64 % of centre); 3.287 GHz to 4.183 GHz (895.6 MHz wide, 24 % of centre) (the widest 3 of 38)
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! magnitudes (dB):
! f  S11  S21  S43  S41  S42  S31  S32
! 300 kHz  -28.8  -46.1  -46.3  -50.0  -0.2  -0.2  -49.6
! 625.3 MHz  -16.4  -10.9  -19.4  -14.5  -7.9  -7.8  -15.1
! 2.238 GHz  -41.6  -21.0  -20.5  -18.4  -19.7  -18.3  -20.1
! 11.78 GHz  -1.3  -9.5  -29.5  -83.6  -77.0  -81.1  -83.8
! 17.79 GHz  3.6  -28.5  -31.7  -77.9  -80.1  -74.7  -70.7
! 19.38 GHz  -3.5  3.4  -28.3  -68.2  -71.9  -72.5  -77.8
! 20 GHz  3.8  -16.0  -29.4  -82.1  -72.6  -75.7  -72.5
