!Agilent Technologies,E5071C,MY46107606,A.09.30
!Date: Mon Dec 14 20:47:48 2009
!Data & Calibration Information:
!Freq	S11:SOLT4(ON)	S12:SOLT4(ON)	S13:SOLT4(ON)	S14:SOLT4(ON)
!	S21:SOLT4(ON)	S22:SOLT4(ON)	S23:SOLT4(ON)	S24:SOLT4(ON)
!	S31:SOLT4(ON)	S32:SOLT4(ON)	S33:SOLT4(ON)	S34:SOLT4(ON)
!	S41:SOLT4(ON)	S42:SOLT4(ON)	S43:SOLT4(ON)	S44:SOLT4(ON)
# Hz S dB R 50
! Worked out from all points (4-port):
!   1601 points, 300 kHz to 20 GHz, reference 50 ohm
!   strongest paths, dB at 300 kHz, 5 GHz, 10 GHz, 15 GHz, 20 GHz:
!     S21: -48.7, -20.7, -16.9, -19.0, -8.3
!     S43: -47.8, -20.7, -22.5, -26.3, -28.3
!     S32: -54.9, -24.5, -42.2, -61.2, -77.2
!     S31: -0.1, -24.4, -43.8, -66.1, -84.2
!     S42: -0.1, -22.6, -45.2, -62.8, -71.0
!     S41: -50.9, -22.4, -46.7, -66.9, -67.4
!   lowest |S11| = -49.6 dB at 62.8 MHz (marker M1), VSWR 1.01, Z = 50.2 + j0.232 ohm
!   |S11| at or under -10 dB: start of sweep to 2.711 GHz; 4.116 GHz to 5.019 GHz (903.9 MHz wide, 19.8 % of centre); 6.921 GHz to 7.661 GHz (740.4 MHz wide, 10.2 % of centre) (the widest 3 of 16)
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! magnitudes (dB):
! f  S11  S21  S43  S32  S31  S42  S41
! 300 kHz  -31.9  -48.7  -47.8  -54.9  -0.1  -0.1  -50.9
! 62.8 MHz  -49.6  -44.7  -26.6  -24.8  -1.3  -1.3  -24.6
! 7.575 GHz  -11.9  -15.8  -27.7  -27.8  -29.4  -29.3  -30.9
! 12.05 GHz  -1.5  -13.4  -25.9  -78.1  -79.9  -82.4  -73.7
! 13.6 GHz  2.3  2.8  -24.5  -49.7  -51.8  -54.1  -59.2
! 14.84 GHz  2.3  -21.8  -29.0  -66.1  -69.8  -68.5  -64.2
! 20 GHz  -1.0  -8.3  -28.3  -77.2  -84.2  -71.0  -67.4
